# Keil uVision project CryptBenchmark.uvprojx, settings and files
target CryptBenchmark (ARM-ADS)
  device: STM32F207IGHx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CryptBenchmark
  c flags: Optim=4
  c define: HAVE_CONFIG_H   MDK_CONF_Benchmark WOLFSSL_USER_SETTINGS
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source
    ./: main.c time-CortexM3-4.c
  group Configuration
    ./RTE/wolfssl/: config-Crypt.h user_settings.h
  group Documentation
    ./: Abstract.txt
software components: CMSIS:CORE 4.1.0, CMSIS:RTOS:Keil RTX 4.78.0, File System:CORE 6.5.0, File System:Drive:Memory Card 6.5.0, CMSIS Driver:MCI 2.02, Compiler:I/O:File 1.0.0, Compiler:I/O:STDERR 1.0.0, Compiler:I/O:STDIN 1.0.0, Compiler:I/O:STDOUT 1.0.0, Device:STM32Cube Framework:Classic 1.0.1, Device:STM32Cube HAL:Common 1.0.1, Device:STM32Cube HAL:Cortex 1.0.1, Device:STM32Cube HAL:DMA 1.0.1, Device:STM32Cube HAL:GPIO 1.0.1, Device:STM32Cube HAL:RCC 1.0.1, Device:Startup 2.0.1, wolfSSL:wolfCrypt:Benchmark , wolfSSL:wolfCrypt:CORE , wolfSSL:wolfCrypt:Dummy 
